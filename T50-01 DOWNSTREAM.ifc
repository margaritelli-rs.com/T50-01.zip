Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: , VersionGUID: d600f4bd-06be-455b-bc53-e534fd662b14, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise]
File name: T50-01 DOWNSTREAM.ifc
Time: 2025-10-19T13:46:07+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ITA) - IFC 23.4.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto

# IfcBuildingStorey: Livello:Livello 1, Livello 1
LongName: Livello 1; Elevation: 0 mm
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello 1; ID tipo: 1899; Tipo: Livello 1
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: Livello 1; Piano edificio: yes; Strutturale: no
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Solido; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello 1

# IfcRailing: T50-01 DOWNSTREAM_R23:T50-01 DOWNSTREAM_R23, T50-01 DOWNSTREAM_R23:T50-01 DOWNSTREAM_R23:10995
In: Livello 1
Type - Material: Metal, wood, <Unnamed>, Black, White
Type - Altro - Categoria: Ringhiere: Supporti; Nome famiglia: T50-01 DOWNSTREAM_R23
Type - Costruzione - Altezza: 125 mm
Type - Dati identità - Acciaio CAM Strade: conforme; ASI: 0.9; Certificazione: crash test; Classe: T50; Classe Box Uscita: Z1; Connessione: H1BL-01 e H2BL-01; Costo: 1031.25; Descrizione: (colore); EPD: no; GWP totale cradle to gate: n.a.; Installazione: Rilevato/Terreno; Legno CAM Strade: CoC PEFC; Livello di Severità: A; Materiale: Acciaio S355J0WP e Legno lamellare GL24H; Modello: T50-01 downstream; Nome del tipo: T50-01 DOWNSTREAM_R23; Norma di Riferimento: CEN/TS 1317-7; Prezzo di Capitolato: 1031.25; Prodotto: Terminale certificato; Produttore: Margaritelli Road Safety; Tipologia: Chiusura; Unità di Misura: N; URL: https://margaritelli-rs.com/it/products/t50-01/; URL (certificati CE. DOP. manuali. schede tecniche. schemi): https://margaritelli-rs.com/it/products/t50-01/
Type - Pset_ManufacturerTypeInformation - Manufacturer: Margaritelli Road Safety
Pset_QuantityTakeOff - Reference: T50-01 DOWNSTREAM_R23
Pset_RailingCommon - Reference: T50-01 DOWNSTREAM_R23; IsExternal: no
Altro - Famiglia: T50-01 DOWNSTREAM_R23; Famiglia e tipo: T50-01 DOWNSTREAM_R23: T50-01 DOWNSTREAM_R23; ID tipo: 10979; Tipo: T50-01 DOWNSTREAM_R23; VISTA_BASEMENT: yes; VISTA_PALO: yes
Vincoli - Gioco mano: 0 mm; Host: Livello : Livello 1; Livello: Livello 1; Offset da host: 0 mm; Sposta con gli elementi più vicini: no
Quote - Area: 2.92117 m2; Volume: 0.0748179 m3
